# Keil uVision project Proj1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051K8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Proj1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Include;.\Source\ModBus;.\Source\MyPeriph
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT5: ROM 0x800f800 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./Source/: main.c mysettings.c ssec.c system_f051.c startup_stm32f0xx.s buttonpush.c playsound.c lockproc.c manualkey.c analize.c
  group MyPeriph
    ./Source/MyPeriph/: mydma.c MyEXTI.c myflash.c mygpio.c myiwdg.c mytimer.c myuart.c fpuart1_051.c
  group ModBus
    ./Source/ModBus/: ModBus.c
    ./Source/: ModBusParams.c
